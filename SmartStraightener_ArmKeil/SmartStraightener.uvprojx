# Keil uVision project SmartStraightener.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.20
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./src/: main.c smartStraightener.c smartStraightener.h
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, Device:Startup 1.0.1
